# IAR project insutest.ewp, settings and files
configuration nrf51822_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51822_xxaa nRF51822_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; NRF_SD_BLE_API_VERSION=2; S130; BOARD_PCA20006; SOFTDEVICE_PRESENT; NRF51822; NRF51; SWI_DISABLE0
  ICCARM.CCIncludePath2: config\insutest; config; components; components\ble\ble_advertising; components\ble\ble_dtm; components\ble\ble_racp; components\ble\ble_services\ble_ancs_c; components\ble\ble_services\ble_ans_c; components\ble\ble_services\ble_bas; components\ble\ble_services\ble_bas_c; components\ble\ble_services\ble_cscs; components\ble\ble_services\ble_cts_c; components\ble\ble_services\ble_dfu; components\ble\ble_services\ble_dis; components\ble\ble_services\ble_gls; components\ble\ble_services\ble_hids; components\ble\ble_services\ble_hrs; components\ble\ble_services\ble_hrs_c; components\ble\ble_services\ble_hts; components\ble\ble_services\ble_ias; components\ble\ble_services\ble_ias_c; components\ble\ble_services\ble_lbs; components\ble\ble_services\ble_lbs_c; components\ble\ble_services\ble_lls; components\ble\ble_services\ble_nus; components\ble\ble_services\ble_nus_c; components\ble\ble_services\ble_rscs; components\ble\ble_services\ble_rscs_c; components\ble\ble_services\ble_tps; components\ble\common; components\ble\nrf_ble_qwr; components\ble\peer_manager; components\boards; components\device; components\drivers_nrf\adc; components\drivers_nrf\clock; components\drivers_nrf\common; components\drivers_nrf\comp; components\drivers_nrf\delay; components\drivers_nrf\gpiote; components\drivers_nrf\hal; components\drivers_nrf\i2s; components\drivers_nrf\lpcomp; components\drivers_nrf\pdm; components\drivers_nrf\power; components\drivers_nrf\ppi; components\drivers_nrf\pwm; components\drivers_nrf\qdec; components\drivers_nrf\rng; components\drivers_nrf\rtc; components\drivers_nrf\saadc; components\drivers_nrf\spi_master; components\drivers_nrf\spi_slave; components\drivers_nrf\swi; components\drivers_nrf\timer; components\drivers_nrf\twi_master; components\drivers_nrf\twis_slave; components\drivers_nrf\uart; components\drivers_nrf\usbd; components\drivers_nrf\wdt; components\libraries\bsp; components\libraries\button; components\libraries\crc16; components\libraries\crc32; components\libraries\csense; components\libraries\csense_drv; components\libraries\experimental_section_vars; components\libraries\fds; components\libraries\fstorage; components\libraries\gpiote; components\libraries\hardfault; components\libraries\hci; components\libraries\led_softblink; components\libraries\log; components\libraries\log\src; components\libraries\low_power_pwm; components\libraries\mem_manager; components\libraries\pwm; components\libraries\queue; components\libraries\scheduler; components\libraries\slip; components\libraries\timer; components\libraries\twi; components\libraries\uart; components\libraries\usbd; components\libraries\usbd\class\audio; components\libraries\usbd\class\cdc; components\libraries\usbd\class\cdc\acm; components\libraries\usbd\class\hid; components\libraries\usbd\class\hid\generic; components\libraries\usbd\class\hid\kbd; components\libraries\usbd\class\hid\mouse; components\libraries\usbd\class\msc; components\libraries\usbd\config; components\libraries\util; components\softdevice\common\softdevice_handler; components\softdevice\s130\headers; components\softdevice\s130\headers\nrf51; components\toolchain; components\toolchain\cmsis\include; external\segger_rtt; config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: insutest.hex
  ILINK.IlinkOutputFile: insutest.out
  ILINK.IlinkIcfFile: nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: ble_gs.c ble_gs.h clock.c clock.h display_SSD1306.c display_SSD1306.h gpio.c gpio.h i2c.c i2c.h main.c
    config/: sdk_config.h
  group Board Definition
    components/boards/: boards.c
  group Device
    components/toolchain/iar/: iar_startup_nrf51.s
    components/toolchain/: system_nrf51.c
  group nRF_BLE
    components/ble/common/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h ble_conn_state.c ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.c ble_srv_common.h
    components/ble/ble_advertising/: ble_advertising.c ble_advertising.h
    components/ble/ble_services/ble_bas/: ble_bas.c ble_bas.h
    components/ble/ble_db_discovery/: ble_db_discovery.c ble_db_discovery.h
    components/ble/ble_services/ble_dis/: ble_dis.c ble_dis.h
    components/ble/ble_services/ble_gls/: ble_gls.c ble_gls.h ble_gls_db.c ble_gls_db.h
    components/ble/ble_services/ble_nus/: ble_nus.c ble_nus.h
    components/ble/ble_services/ble_nus_c/: ble_nus_c.c ble_nus_c.h
    components/ble/ble_racp/: ble_racp.c ble_racp.h
    components/ble/peer_manager/: gatt_cache_manager.c gatt_cache_manager.h gatts_cache_manager.c gatts_cache_manager.h id_manager.c id_manager.h peer_data.c peer_data.h peer_data_storage.c peer_data_storage.h peer_database.c peer_database.h peer_id.c peer_id.h peer_manager.c peer_manager.h peer_manager_internal.h peer_manager_types.h pm_buffer.c pm_buffer.h pm_mutex.c pm_mutex.h security_dispatcher.c security_dispatcher.h security_manager.c security_manager.h
  group nRF_Drivers
    components/drivers_nrf/clock/: nrf_drv_clock.c
    components/drivers_nrf/common/: nrf_drv_common.c
    components/drivers_nrf/twi_master/: nrf_drv_twi.c
    components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    components/libraries/button/: app_button.c
    components/libraries/util/: app_error.c app_error.h app_error_weak.c app_error_weak.h app_util.h app_util_bds.h app_util_platform.c app_util_platform.h nordic_common.h nrf_assert.c nrf_assert.h nrf_bitmask.h sdk_common.h sdk_errors.c sdk_errors.h sdk_macros.h sdk_mapped_flags.c sdk_mapped_flags.h sdk_os.h sdk_resources.h
    components/libraries/timer/: app_timer.c
    components/libraries/fds/: fds.c fds.h fds_internal_defs.h
    components/libraries/fstorage/: fstorage.c fstorage.h fstorage_internal_defs.h fstorage_nosd.c
    components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    components/softdevice/common/softdevice_handler/: softdevice_handler.c
